# Keil uVision project DR-05.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32F033 Cmsemicon
  pack: Cmsemicon.CMS32-Series.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: DR-05
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=1
  c include: ..\MDK_APP;..\MDK_Drive_Library\Inc;..\MDK_Hardware\Beep;..\MDK_Hardware\Bluetooth;..\MDK_Hardware\Key;..\MDK_Hardware\LED;..\MDK_System;..\MDK_User;..\MDK_Drive_Library\Inc\Cmsis;..\MDK_Drive_Library\Inc\Mcu;..\MDK_Drive_Library\Inc\Psfr;..\MDK_Hardware\Fan
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MDK_USER
    ../MDK_USER/: main.c
    ../MDK_User/: cms32f033_it.c MyTypedef.c Timing.c
  group MDK_System
    ../MDK_System/: ccp.c epwm.c sys.c SystemConfig.c Timer.c usart.c adc.c
  group MDK_Lib\Scr\MCU
    ../MDK_Drive_Library/Src/Mcu/: system_cms32f033x.c startup_cms32f033x.s
  group MDK_Lib\Scr\Psfr
    ../MDK_Drive_Library/Src/Psfr/: Psfr_acmp.c Psfr_adc.c Psfr_ccp.c Psfr_crc.c Psfr_epwm.c Psfr_fmc.c Psfr_gpio.c Psfr_hwdiv.c Psfr_i2c.c Psfr_opa.c Psfr_pga.c Psfr_retarget.c Psfr_ssp.c Psfr_system.c Psfr_tick.c Psfr_timer.c Psfr_uart.c Psfr_wdt.c Psfr_wwdt.c
  group MDK_Hardware
    ../MDK_Hardware/Beep/: bsp_beep.c
    ../MDK_Hardware/Bluetooth/: bluetooth.c
    ../MDK_Hardware/Key/: bsp_key.c
    ../MDK_Hardware/LED/: bsp_led.c
  group MDK_APP
    ../MDK_APP/: emsCtrl.c Protocol_app.c sn74hc21d.c templist.c emsPID.c oldTest.c k1Ctrl.c eptCtrl.c sneCtrl.c masCtrl.c
    ../MDK_System/: flash.c
