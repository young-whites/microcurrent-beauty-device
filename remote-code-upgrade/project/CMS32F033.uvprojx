# Keil uVision project CMS32F033.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32F033 Cmsemicon
  pack: Cmsemicon.CMS32-Series.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: CMS32F033 +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\code\CMSIS\Include;..\code\head\0_global_h;..\code\head\1_driver_h;..\code\head\2_app_h;..\code\head\3_user_h;..\user\inc;..\radio;..\code
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../code/source/0_global_s/: startup_cms32f033.s system_cms32f033.c
  group Driver
    ../code/source/1_driver_s/: acmp.c adc1.c ccp.c crc.c epwm.c gpio.c hwdiv.c i2c.c opa.c pga.c retarget.c ssp.c system.c timer.c uart.c wdt.c wwdt.c fmc.c
  group App
    ../code/source/2_app_s/: app_acmp.c app_adc1.c app_ccp.c app_crc.c app_epwm.c app_gpio.c app_hwdiv.c app_i2c.c app_opa.c app_pga.c app_spi.c app_system.c app_timer.c app_uart.c app_wdt.c app_wwdt.c
  group User
    ../user/src/: main.c isr.c Device_Init.c clock.c gpioctl.c bsp_usrt.c Ymode.c flash_operate.c
